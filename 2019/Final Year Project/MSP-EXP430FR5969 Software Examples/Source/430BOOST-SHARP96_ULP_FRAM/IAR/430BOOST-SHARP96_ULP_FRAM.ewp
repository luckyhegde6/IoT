# IAR project 430BOOST-SHARP96_ULP_FRAM.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../; ../driverlib/MSP430FR5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430fr5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: ActivePowerMeasure.c ActivePowerMeasure.h ClockApp.c ClockApp.h FR59xx_EXP.c FR59xx_EXP.h FRAMSpeedApp.c FRAMSpeedApp.h Game.c Game.h msp430fr59xx_CHR.h msp430fr59xx_CHR.s43 myTimer.c myTimer.h ULPMeter.c ULPMeter.h UpdateDisplay.c UpdateDisplay.h
    ./: low_level_init.c
  group CTS
    ../CTS/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h CTS_wolverine.c CTS_wolverine.h structure.c structure.h
  group driverlib/MSP430FR5xx_6xx
    ../driverlib/MSP430FR5xx_6xx/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h cs.c cs.h dma.c dma.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h fram.c fram.h gpio.c gpio.h mpu.c mpu.h mpy32.c mpy32.h pmm.c pmm.h ref_a.c ref_a.h rtc_b.c rtc_b.h sfr.c sfr.h sys.c sys.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR5xx_6xx/deprecated/CCS
    ../driverlib/MSP430FR5xx_6xx/deprecated/CCS/: in430.h msp430xgeneric.h
  group driverlib/MSP430FR5xx_6xx/deprecated/IAR
    ../driverlib/MSP430FR5xx_6xx/deprecated/IAR/: msp430xgeneric.h
  group driverlib/MSP430FR5xx_6xx/inc
    ../driverlib/MSP430FR5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h
  group grlib
    ../grlib/: sharp96x96.c sharp96x96.h Sharp96x96utils.h Sharp96x96utils.s43
  group grlib/grlib
    ../grlib/grlib/: circle.c context.c fontcmss12.c fontcmss32.c grlib.h image.c line.c rectangle.c string.c
  group Preloaded_Images
    ../Preloaded_Images/: TI_logo.h Wolverine_slash.h
