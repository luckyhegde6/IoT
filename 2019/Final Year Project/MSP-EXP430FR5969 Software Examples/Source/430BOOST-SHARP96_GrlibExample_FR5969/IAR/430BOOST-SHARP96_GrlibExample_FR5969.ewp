# IAR project 430BOOST-SHARP96_GrlibExample_FR5969.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\; ..\grlib\; ..\fonts\; ..\LcdDriver\; ..\images\; ..\driverlib\MSP430FR5xx_6xx\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: driverlibHeaders.h main.c
  group driverlib/MSP430FR5xx_6xx
    ../driverlib/MSP430FR5xx_6xx/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h cs.c cs.h dma.c dma.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_a_uartbaudrate.c eusci_a_uartbaudrate.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h fram.c fram.h gpio.c gpio.h mpu.c mpu.h mpy32.c mpy32.h pmm.c pmm.h ref_a.c ref_a.h rtc_b.c rtc_b.h sfr.c sfr.h sys.c sys.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR5xx_6xx/deprecated/IAR
    ../driverlib/MSP430FR5xx_6xx/deprecated/IAR/: msp430xgeneric.h
  group driverlib/MSP430FR5xx_6xx/inc
    ../driverlib/MSP430FR5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h
  group fonts
    ../fonts/: fontfixed6x8.c
  group grlib
    ../grlib/: circle.c context.c grlib.h image.c line.c rectangle.c string.c
  group Images
    ../images/: images.h LPRocket_96x37.c TI_Logo_69x64.c
  group LcdDriver
    ../LcdDriver/: HAL_MSP-EXP430FR5969_Sharp96x96.c HAL_MSP-EXP430FR5969_Sharp96x96.h Sharp96x96.c Sharp96x96.h
